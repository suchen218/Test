# Keil uVision project template.uvprojx, settings and files
target template_Release (6160000::V6.16::ARMCLANG)
  device: HC32L130J8TA HDSC
  pack: HDSC.HC32L130.1.0.1
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 wLevel=4
  c define: DEBUG_PRINT
  c include: ..\..\..\mcu\common;..\source;..\..\..\driver\inc;..\source\bsp;..\source\segger_rtt
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32l13x.s
    ../../../mcu/common/: system_hc32l13x.c interrupts_hc32l13x.c
  group source
    ../source/: main.c
    ../source/bsp/: bsp_air.c bsp_ctrl.c bsp_limiter.c bsp_motor.c bsp_msg.c bsp_pir.c bsp_timer.c bsp_uv.c bsp_water.c bsp_wifi.c bsp_debug.c
  group driver
    ../../../driver/src/: ddl.c sysctrl.c adt.c bt.c gpio.c uart.c wdt.c flash.c
  group README
    ../: readme.txt
  group RTT
    ../source/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c
software components: CMSIS:CORE 5.5.0
