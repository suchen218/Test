# Keil uVision project lcd_mode.uvprojx, settings and files
target lcd_mode_Release (6160000::V6.16::ARMCLANG)
  device: HC32L136K8TA HDSC
  pack: HDSC.HC32L136.1.0.1
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: lcd_mode +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 wLevel=4
  c include: ..\..\..\..\mcu\common;..\source;..\..\..\..\driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32l13x.s
    ../../../../mcu/common/: system_hc32l13x.c interrupts_hc32l13x.c
  group source
    ../source/: main.c
  group driver
    ../../../../driver/src/: ddl.c sysctrl.c lcd.c lpm.c gpio.c
  group README
    ../: readme.txt
software components: CMSIS:CORE 5.5.0
